# Keil uVision project Hurri-Cargo_Code.uvprojx, settings and files
target Hurri-Cargo_Code (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Hurri-Cargo_Code +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,STM32_THREAD_SAFE_STRATEGY=4
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Drivers/User/ADC;../Drivers/User/MISC;../Drivers/User/OPS;../Drivers/User/RTOS;../Drivers/User/SCANNER;../Drivers/User/STEP;../Applications/ANSI_Art;../Applications/chassis;../Applications/letter_shell;../Applications/nav;../Applications/Planner;../Applications/Planner/tools;../Applications/Planner/utils;../Applications/letter_shell/log;../Applications/letter_shell/shell_enhance;../Applications/letter_shell/src;../Middlewares/ST/ARM/DSP/Inc
  asm include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/ARM/DSP/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s armlib_lock_glue.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c dma.c iwdg.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group ADC
    ../Drivers/User/ADC/: Battery.c
  group MISC
    ../Drivers/User/MISC/: message.c
  group OPS
    ../Drivers/User/OPS/: ops.c
  group RTOS
    ../Drivers/User/RTOS/: rtos_utils.c
  group SCANNER
    ../Drivers/User/SCANNER/: scan_driver.c
  group STEP
    ../Drivers/User/STEP/: step_port_dlc.c zdt_v5_port.c
  group ANSI_Art
    ../Applications/ANSI_Art/: Art_Data.c Art_show.c
  group chassis
    ../Applications/chassis/: chassis.c
    ../Applications/chassis/motion/: motion_control.c
    ../Applications/chassis/kinematics/: kinematics.c
  group letter_shell
    ../Applications/letter_shell/: shell_port.c
    ../Applications/letter_shell/src/: shell.c shell_cmd_list.c shell_companion.c shell_ext.c
    ../Applications/letter_shell/shell_enhance/: shell_cmd_group.c
    ../Applications/letter_shell/log/: log.c
  group nav
    ../Applications/nav/: nav_core.c nav_map.c nav_map_data.c
    ../Applications/nav/utils/: nav_math.c
    ../Applications/nav/tools/: nav_tools.c
    ../Applications/nav/localization/: nav_local.c
  group PLANNER
    ../Applications/Planner/: planner_port.c
    ../Applications/Planner/utils/: Cstar_map_core.c planner_algo.c priority_queue.c
    ../Applications/Planner/tools/: planner_tools.c
  group Middlewares/Library/DSP Library/DSP Library
    ./: 
    ../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM4lf_math.lib
software components: CMSIS:CORE 4.3.0
